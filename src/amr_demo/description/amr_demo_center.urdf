Commit message: update

File: src/amr_demo/description/amr_demo_center.urdf (robot description, URDF)
Before this commit: robot amr, 7 links, 6 joints
Joints:
- joint lidar_joint: origin xyz=0.0 0.0 0.04 rpy=3.14 0 -3.14 -> xyz=0.0 0.0 0.04 rpy=0 0 -3.14
